Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 00_Ensamblaje completo B2_20260210_BIM SIN TORNILLOS PART TODO IFC V11 ENSAM.IFC
Time: 2026-02-13T08:44:10
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 0.9435_20260210_BIM (2)
In: Default Storey
Material: PVC

# IfcBuildingElementProxy: 1.0510_20260210_BIM_Curvado en taller (2)
In: Default Storey
Material: AISI 316 Barra de acero inoxidable recocido (SS)

# IfcBuildingElementProxy: 1.0520_20260210_BIM
In: Default Storey
Material: AISI 316 Barra de acero inoxidable

# IfcBuildingElementProxy: 1.2505_20260210_BIM
In: Default Storey
Material: AISI 316 Chapa de acero inoxidable

# IfcBuildingElementProxy: 319 Carcasa silla
In: Default Storey
Material: ABS
